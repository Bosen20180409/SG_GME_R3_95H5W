# Keil uVision project Custom_HID.uvprojx, settings and files
target MM32F062PF (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MM32L073PT MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Custom_HID +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\App;..\Common;..\Drive;..\Libraries\HAL_lib\inc;..\Libraries\Include;..\Libraries\Source\KEIL_StartAsm;..\Libraries\USB_lib\inc;..\SX1212;..\SX1212\Packet;..\USB_Config;..\..\..\..\Definition
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group App
    ../App/: main.c config.c config.h SysInfo.c SysInfo.h SysLoop.c SysLoop.h MM32L073_it.c
  group Drive
    ../Drive/: Led.c STM32_Timer.c STM32_Usart1.c STM32_Usart2.c ParseSrcData.c GpioDet.c HC165.c STM32SPI.c STM32_Adc.c STM32_Adc.h
  group SX2122
    ../SX1212/: SX1212RxTx.c SX1212RxTx.h
    ../SX1212/Packet/: SX1212Driver.c SX1212Driver.h
  group Common
    ../Common/: Delay.c Initial.c
  group USB_lib
    ../Libraries/USB_lib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group USB_Config
    ../USB_Config/: hw_config.c hw_config.h usb_conf.h usb_desc.h usb_desc_pc.c usb_desc_pc.h usb_desc_ps3.c usb_desc_ps3.h usb_desc_ps4.c usb_desc_ps4.h usb_istr.c usb_istr.h usb_prop.c usb_prop.h usb_pwr.c usb_pwr.h usb_sil.c usb_sil.h
  group HAL_lib
    ../Libraries/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group System
    ../Libraries/Source/: system_MM32L0xx.c
    ../Libraries/Source/KEIL_StartAsm/: startup_MM32L0xx.s
  group Doc
    ../: readme.txt
